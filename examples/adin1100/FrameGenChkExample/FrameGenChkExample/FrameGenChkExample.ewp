# IAR project FrameGenChkExample.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ADIN1100; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..\..\..\..\inc; ..\..\..\..\common; ..\..\..\bsp\eval_adin11xx; ..\src; ..\..\..\..\common\hal; ..\..\..\..\common\hal\ports\aducm4050
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: FrameGenChkExample.hex
  ILINK.IlinkOutputFile: FrameGenChkExample.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.FPU2: 4
  ICCARM.CCDefines: ADIN1100; NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group adin1100 Driver
    ../../../../src/: adi_phy.c adin1100.c
  group bsp
    ../../../bsp/eval_adin11xx/: boardsupport.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device Global Configuration
    RTE/Device/ADuCM4050/: adi_cycle_counting_config.h adi_global_config.h
  group CMSIS-Pack/Device Startup
    RTE/Device/ADuCM4050/: startup_ADuCM4050.s system_ADuCM4050.c system_ADuCM4050.h
  group CMSIS-Pack/Device.Drivers DMA
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.3.0}$/Source/drivers/dma/: adi_dma.c
  group CMSIS-Pack/Device.Drivers GPIO
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.3.0}$/Source/drivers/gpio/: adi_gpio.c
  group CMSIS-Pack/Device.Drivers Interrupt
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.3.0}$/Source/drivers/xint/: adi_xint.c
  group CMSIS-Pack/Device.Drivers Power
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.3.0}$/Source/drivers/pwr/: adi_pwr.c
    RTE/Device/ADuCM4050/: adi_pwr_config.h
  group CMSIS-Pack/Device.Drivers SPI
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.3.0}$/Source/drivers/spi/: adi_spi.c
    RTE/Device/ADuCM4050/: adi_spi_config.h
  group CMSIS-Pack/Device.Drivers TMR
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.3.0}$/Source/drivers/tmr/: adi_tmr.c
    RTE/Device/ADuCM4050/: adi_tmr_config.h
  group CMSIS-Pack/Device.Drivers UART
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.3.0}$/Source/drivers/uart/: adi_uart.c
    RTE/Device/ADuCM4050/: adi_uart_config.h
  group CMSIS-Pack/Device.Drivers WDT
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM4x50_DFP#3.3.0}$/Source/drivers/wdt/: adi_wdt.c
    RTE/Device/ADuCM4050/: adi_wdt_config.h
  group hal/ports
    ../../../../common/hal/ports/aducm4050/: adi_platform.c hal.c
  group hal/ports/mdio_gpio
    ../../../../common/hal/mdio_gpio/: mdio_gpio.c
  group src
    ../src/: main.c pinmux.c

<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SimpleLink\SimpleLink.ewp</path>
    </project>
    <batchBuild />
</workspace>
